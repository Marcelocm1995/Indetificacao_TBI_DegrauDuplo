# Keil uVision project ViscousFrictionalCoefficient.uvprojx, settings and files
target StalledMotorIndutance (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: StaticLoadTest +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Filter;..\Map
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../MDK-ARM/: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c adc.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: ViscousFrictionalCoefficient.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Filter
    ../Filter/: filter_1order.c
  group Map
    ../Map/: Map.c
software components: CMSIS:CORE 5.6.0
